# IAR project Project.ewp, settings and files
configuration NucleoF401RE-BLESTAR1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils; ..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\Middlewares\Third_Parties\paho.mqtt.embedded-c\MQTTClient-C\src; ..\..\..\..\..\Middlewares\Third_Parties\paho.mqtt.embedded-c\MQTTPacket\src; ..\..\..\..\..\Middlewares\Third_Parties\paho.mqtt.embedded-c\Utils; ..\..\..\..\..\Middlewares\Third_Parties\paho.mqtt.embedded-c\Porting; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1; ..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLESTAR1_F401RE.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: ble_master_service.c ble_slave_service.c console.c cube_hal_f4.c IBM_Bluemix_Config.c main.c stm32f4xx_hal_msp.c stm32xx_it.c wifi_support.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/BSP/X-NUCLEO-IDW0xx1
    ../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/ST/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/ST/STM32_BlueNRG/HCI/controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/ST/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/ST/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
  group Middlewares/ST/STM32_SPWF01SA
    ../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_interface.c wifi_module.c
  group Middlewares/ST/STM32_SPWF01SA/Utils
    ../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: event_buffer.c ring_buffer.c wifi_globals.c
  group Middlewares/Third_Parties/MQTT-Paho
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/Porting/: MQTT_SPWF_interface.c
  group Middlewares/Third_Parties/MQTT-Paho/MQTTClient-C
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/Third_Parties/MQTT-Paho/MQTTPacket
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Middlewares/Third_Parties/MQTT-Paho/Utils
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/Utils/: TLocalBuffer.c
