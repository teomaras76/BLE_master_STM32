# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_BLESTAR_IDB05A1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: BLESTAR
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_STM32L475E_IOT01,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<bluemix_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,_UINTPTR_T,MOSQUITTO,BLUEMIX,USE_WIFI,USE_WIFI_IOT01,USE_BLUENRG_EXT
  c include: ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/B-L475E-IOT01;../Inc;../Common/Shared/Inc;../Common/Bluemix/Inc;../../../../../Middlewares/ST/STM32_BlueNRG/Interface;../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/includes;../../../../../Middlewares/Third_Parties/mbedTLS/include;../../../../../Middlewares/Third_Parties/Bluemix/src;../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../Middlewares/Third_Parties/cmocka/include;../../../../../Middlewares/Third_Parties/cJSON;../../../../../Drivers/BSP/Components/es_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/BLE
    ../Src/: ble_slave_service.c ble_master_service.c
  group Application/Bluemix
    ../Common/Bluemix/src/: iotf_network_tls_wrapper.c bluemix.c
  group Application/Common
    ../Common/Shared/Src/: mbedtls_net.c STM32CubeRTCInterface.c rfu.c net_tcp_wifi.c http_util.c iot_flash_config.c timer.c timedate.c cloud.c timingSystem.c net_tls_mbedtls.c wifi_net.c net.c heap.c entropy_hardware_poll.c
    ../Src/: flash_l4.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c main.c stm32l4xx_it.c
  group Application/Wifi
    ../Src/: wifi.c es_wifi_io.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32_bluenrg_ble.c
  group Drivers/BSP/Components/es_wifi
    ../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_hash.c stm32l4xx_hal_rcc.c stm32l4xx_hal_sram.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_dma.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal.c stm32l4xx_hal_spi.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_fmc.c
  group Middlewares/ST/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/ST/STM32_BlueNRG/HCI/controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_updater_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_gap_aci.c
  group Middlewares/ST/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/ST/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: osal.c ble_list.c gp_timer.c
  group Middlewares/Third_Parties/Bluemix
    ../../../../../Middlewares/Third_Parties/Bluemix/src/: devicemanagementclient.c deviceclient.c iotf_utils.c iotfclient.c
  group Middlewares/Third_Parties/cJSON
    ../../../../../Middlewares/Third_Parties/cJSON/: cJSON_Utils.c cJSON.c
  group Middlewares/Third_Parties/Cmocka
    ../../../../../Middlewares/Third_Parties/cmocka/src/: cmocka.c
  group Middlewares/Third_Parties/MbedTLS
    ../../../../../Middlewares/Third_Parties/mbedTLS/library/: ssl_cli.c padlock.c camellia.c ripemd160.c ssl_ciphersuites.c oid.c ssl_cache.c xtea.c pkcs5.c rsa.c ecp_curves.c base64.c version_features.c version.c gcm.c x509.c sha1.c aes.c md.c x509_crl.c debug.c timing.c ccm.c ctr_drbg.c cipher_wrap.c aesni.c x509_create.c ecjpake.c dhm.c pkcs11.c platform.c x509_crt.c certs.c havege.c md5.c arc4.c md_wrap.c pk_wrap.c memory_buffer_alloc.c md4.c sha256.c cipher.c entropy.c blowfish.c pk.c ecdsa.c bignum.c x509write_crt.c ssl_ticket.c pem.c threading.c sha512.c x509_csr.c des.c ssl_cookie.c pkwrite.c ecp.c md2.c asn1write.c error.c x509write_csr.c hmac_drbg.c cmac.c pkparse.c ssl_srv.c asn1parse.c entropy_poll.c pkcs12.c ecdh.c ssl_tls.c
  group Middlewares/Third_Parties/MQTTPacket
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeServer.c MQTTDeserializePublish.c MQTTUnsubscribeClient.c MQTTSubscribeClient.c MQTTFormat.c MQTTUnsubscribeServer.c MQTTConnectClient.c MQTTConnectServer.c
  group Middlewares/Third_Parties/MQTTClient-C
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
target B-L475E-IOT01_BLESTAR (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_STM32L475E_IOT01,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<bluemix_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,_UINTPTR_T,MOSQUITTO,BLUEMIX,USE_WIFI,USE_WIFI_IOT01
  c include: as above
  library: MicroLIB
  scatter file: .\B-L475E-IOT01.sct
software components: CMSIS:CORE 4.3.0
