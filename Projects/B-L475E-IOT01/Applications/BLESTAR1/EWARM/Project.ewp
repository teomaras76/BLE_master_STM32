# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01_BLESTAR_IDB05A1 (ARM)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_STM32L475E_IOT01; USE_HAL_DRIVER; MBEDTLS_CONFIG_FILE=<bluemix_mbedtls_config.h>; MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; USE_MBED_TLS; _UINTPTR_T; MOSQUITTO; BLUEMIX; USE_WIFI; USE_WIFI_IOT01; USE_BLUENRG_EXT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\B-L475E-IOT01; ..\Inc; ..\Common\Shared\Inc; ..\Common\Bluemix\Inc; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\Middlewares\Third_Parties\mbedTLS\include; ..\..\..\..\..\Middlewares\Third_Parties\Bluemix\src; ..\..\..\..\..\Middlewares\Third_Parties\paho.mqtt.embedded-c\MQTTPacket\src; ..\..\..\..\..\Middlewares\Third_Parties\paho.mqtt.embedded-c\MQTTClient-C\src; ..\..\..\..\..\Middlewares\Third_Parties\cmocka\include; ..\..\..\..\..\Middlewares\Third_Parties\cJSON; ..\..\..\..\..\Drivers\BSP\Components\es_wifi
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLESTAR1_B-L475E-IOT01_IDB05A1.bin
  ILINK.IlinkOutputFile: B-L475E-IOT01.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration B-L475E-IOT01_BLESTAR (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L475xx; USE_STM32L475E_IOT01; USE_HAL_DRIVER; MBEDTLS_CONFIG_FILE=<bluemix_mbedtls_config.h>; MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; USE_MBED_TLS; _UINTPTR_T; MOSQUITTO; BLUEMIX; USE_WIFI; USE_WIFI_IOT01
  OBJCOPY.OOCOutputFile: BLESTAR1_B-L475E-IOT01.bin
  group Application/BLE
    ../Src/: ble_master_service.c ble_slave_service.c
  group Application/Bluemix
    ../Common/Bluemix/src/: bluemix.c iotf_network_tls_wrapper.c
  group Application/Common
    ../Common/Shared/Src/: cloud.c entropy_hardware_poll.c heap.c http_util.c iot_flash_config.c mbedtls_net.c net.c net_tcp_wifi.c net_tls_mbedtls.c rfu.c STM32CubeRTCInterface.c timedate.c timer.c timingSystem.c wifi_net.c
    ../Src/: flash_l4.c
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/Wifi
    ../Src/: es_wifi_io.c wifi.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../Drivers/BSP/B-L475E-IOT01/: stm32_bluenrg_ble.c stm32l475e_iot01.c
  group Drivers/BSP/Components/es_wifi
    ../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_fmc.c
  group Middlewares/ST/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/ST/STM32_BlueNRG/HCI/controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/ST/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/ST/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
  group Middlewares/Third_Parties/Bluemix
    ../../../../../Middlewares/Third_Parties/Bluemix/src/: deviceclient.c devicemanagementclient.c iotf_utils.c iotfclient.c
  group Middlewares/Third_Parties/cJSON
    ../../../../../Middlewares/Third_Parties/cJSON/: cJSON.c cJSON_Utils.c
  group Middlewares/Third_Parties/Cmocka
    ../../../../../Middlewares/Third_Parties/cmocka/src/: cmocka.c
  group Middlewares/Third_Parties/MbedTLS
    ../../../../../Middlewares/Third_Parties/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/Third_Parties/MQTTClient-C
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/Third_Parties/MQTTPacket
    ../../../../../Middlewares/Third_Parties/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
